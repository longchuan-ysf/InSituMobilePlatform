# Keil uVision project EMB8628I.uvprojx, settings and files
target EMB8628I (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EMB8628I_APP +hex
  AfterMake: fromelf --bin --output .\output\bin\EMB8628I_APP.bin .\output\EMB8628I_APP.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: EMB8628I_TYPE
  c include: ..;..\..\uCOS-II\uC-CPU\ARM-Cortex-M4;..\..\uCOS-II\uC-LIB\ARM-Cortex-M4;..\..\uCOS-II\Ports\ARM-Cortex-M4;..\..\uCOS-II\Source;..\..\source;..\..\Config;..\..\FatFS\source;..\..\lwip-1.4.1\src\include\lwip;..\..\lwip-1.4.1\src\include;..\..\lwip-1.4.1\src\core\ipv4;..\..\lwip-1.4.1\src\core;..\..\lwip-1.4.1\src\include\ipv4;..\..\lwip-1.4.1\port;..\..\lwip-1.4.1\src;..\..\lwip-1.4.1\src\netif;..\..\init;..\..\Libraries;..\..\lwip-1.4.1\src\api;..\..\lwip-1.4.1\src\arch;..\..\OSConfig;.\Config;..\..\APP\Driver\Inc;..\..\APP\ComFunction\Inc;..\..\APP\HMI\Inc;..\..\APP\MovePlatform\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\config\STM32F407XE_Flash.scat
  link misc: --entry ResetHndlr
  group config
    ../../config/: vars.c const.h config.h
    ./config/: EMB8628I_Config.h EMB8628I_IOConfig.h
  group OSConfig
    ../../osconfig/: app_cfg.h os_cfg.h OSHook.c OSVars.c OSHook.h OSVars.h
  group Libraries
    ../../Libraries/: adc.h at45dbxx.h bkp.h can.h crc.h dac.h delay.h eeprom.h exti.h flash.h fsmc.h gpio.h i2c.h iap.h iwdg.h modbus.h net.h NFlash.h rtc.h sd.h spi.h STM32Fxxx.h subfun.h sysint.h timer.h Uart.h USBDevice.h USBHost.h W25Qxx.h lib_readme.txt STM32F407XX_V110_20200824.lib
  group init
    ../../init/: inita.s vectors.s
  group fatfs
    ../../FatFS/source/: diskio.c ff.c ffunicode.c ffsystem.c diskio.h ff.h integer.h ffconf.h
  group lwip
    ../../lwip-1.4.1/: lwip.c
    ../../lwip-1.4.1/src/arch/: sys_arch.c
    ../../lwip-1.4.1/port/: ethernetif.c lwipopts.h
    ../../lwip-1.4.1/src/include/lwip/: opt.h
  group ucos-ii
    ../../uCOS-II/: ucos-ii.c
    ../../uCOS-II/Ports/ARM-Cortex-M4/: os_cpu_a.asm
    ../../uCOS-II/uC-CPU/ARM-Cortex-M4/: cpu_a.asm
    ../../uCOS-II/uC-LIB/ARM-Cortex-M4/: lib_mem_a.asm
  group APP/Main
    ../../source/: APP_Init.c APP_Init.h AT.c AT.h ISRHook.c ISRHook.h main.c TaskADC_DAC.c TaskDTU.c TaskFile.c TaskIO.c TaskLWIP.c TaskModbus.c TaskPWMFClk.c TaskUartCan.c UserVars.c UserVars.h CH455.c
  group APP/MobilePlatform
    ../../APP/MovePlatform/Src/: PlatformManage.c PlatformDriveTask.c PlatformDrive.c
  group APP/Driver
    ../../APP/Driver/Src/: GPIO_Manager.c motor.c
  group APP/ComFunction
    ../../APP/ComFunction/Src/: fifo.c fun.c mylist.c
  group APP/HMI_APP
    ../../APP/HMI/Src/: hmi_app.c hmi_functionHandle.c hmi_WidgetHandle.c
  group APP/HM_Driver
    ../../APP/HMI/Src/: cmd_queue.c hmi_driver.c hmi_user_uart.c
  group readme
    ../../doc/: readme.txt
software components: CMSIS:CORE 5.0.1
